# IAR project Sora_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 NXP MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MKV58F1M0VLQ24; TWR_KV58F220M; TOWER; ARM_MATH_CM7; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT; __FPU_USED
  ICCARM.CCIncludePath2: board; source; CMSIS; board/src; doc; drivers; startup; utilities; middleware; middleware/dma_manager; device
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: board; source; CMSIS; board/src; doc; drivers; startup; utilities
  OBJCOPY.OOCOutputFile: Sora_lib.srec
  ILINK.IlinkOutputFile: Sora_lib.out
  ILINK.IlinkIcfFile: MKV58F1M0xxx24_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board
    board/: pin_mux.c pin_mux.h
  group board/src
    board/src/: clock_config.c clock_config.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm7.h fsl_device_registers.h MKV58F24.h MKV58F24_features.h mpu_armv7.h mpu_armv8.h system_MKV58F24.c system_MKV58F24.h
  group device
    device/: sora_camera.c sora_camera.h sora_camera_mt9v032.c sora_camera_mt9v032.h sora_lcd.c sora_lcd.h
  group drivers
    drivers/: fsl_adc16.c fsl_adc16.h fsl_aoi.c fsl_aoi.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_hsadc.c fsl_hsadc.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_pwm.c fsl_pwm.h fsl_rcm.c fsl_rcm.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_trng.c fsl_trng.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group middleware/dma_manager
    middleware/dma_manager/: fsl_dma_manager.c fsl_dma_manager.h
  group source
    source/: common.h include.h main.c sora_dwt.c sora_dwt.h sora_edma.c sora_edma.h sora_enc.c sora_enc.h sora_gpio.c sora_gpio.h sora_gpio_cfg.h sora_lptmr.c sora_lptmr.h sora_pit.c sora_pit.h sora_port.c sora_port.h sora_pwm.c sora_pwm.h sora_system.c sora_system.h sora_uart.c sora_uart.h
  group startup
    startup/: startup_MKV58F24.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_shell.c fsl_shell.h fsl_str.c fsl_str.h fsl_swo.c fsl_swo.h
